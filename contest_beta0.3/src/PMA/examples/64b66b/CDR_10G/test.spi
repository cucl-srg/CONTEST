***  Written by Yury Audzevich
***
***  Comments, suggestions for improvement and criticism welcome
***  E-mail:  yury.audzevich~at~cl.cam.ac.uk
***
***
***  Copyright 2003-2013, University of Cambridge, Computer Laboratory.
***  Copyright and related rights are licensed under the Hardware License,
***  Version 2.0 (the "License"); you may not use this file except in
***  compliance with the License. You may obtain a copy of the License at
***  http://www.cl.cam.ac.uk/research/srg/netos/greenict/projects/contest/.
***  Unless required by applicable law or agreed to in writing, software,
***  hardware and materials distributed under this License is distributed
***  on an "AS IS" BASIS, WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND,
***  either express or implied. See the License for the specific language
***  governing permissions and limitations under the License.
***
***

***** HSPICE simulation using standard cell designs *****

***** 45nm predictive technology model (FreePDK v1.4)  Typical conditions, 1.1V, 25C *****
.include "/usr/groups/ecad/kits/commercial45_v2010_12/n45-hspice-model-TT_1V10_25.spi"

***** Standard CMOS library *****
.include "/usr/groups/ecad/kits/commercial45_v2010_12/n45-library-netlist-noparasitics.spi"

*********************************************
***************** OPTIONS *******************
*********************************************
.option post
.option nomod
.option co=255
.option dcon=1
.option lis_new=1
.option accurate

***** Optionally probe only the signals that are required to speed up simulation *****
.probe V(VDD*) V(VSS*)
.probe V(V*)

*********************************************
************** MEASUREMENTS *****************
*********************************************
**** type of analysis - transient ****
.tran FROM_TS TO_TS

*** parameters ****
.include "params_cells.spi"

*** POWER meas. (custom) and frequency generated by PLL
.include "POWER_PLL.spi"

***** Drive inputs using stimulus in "test.dsi", configure driver widths *****
.include "tempdir.stimulus/test-stim.sp"

***** gate-level netlist PLL, basic MCML cells *****
.include "PLL_main.spi"
.include "MCML_cells.spi"

*********************************************
*********** POWER SUPPLY DEFs ***************
*********************************************
*** MCML supplies
Vvdd VDD 0 PARAM_MCML_VDD_VOLTAGE
Vsss VSS 0 PARAM_MCML_VSS_VOLTAGE

*** level shifting
Vls VLEV 0 DC PARAM_LEVEL_SHIFT_VOLTAGE

*** other supplies CMOS VDD + OPAMP related
Vvdd_cmos VDD_CMOS 0 DC PARAM_CMOS_VDD
Vvss_cmos VSS_CMOS 0 DC PARAM_CMOS_VSS
*
Vvdd_opamp VDD_OPAMP 0 DC PARAM_CMOS_VDD
Vvss_opamp VSS_OPAMP 0 DC PARAM_CMOS_VSS
Vvrefn VREFN_I 0 PARAM_OP_N_BIAS_VOLTAGE
Vvrefp VREFP_I 0 PARAM_OP_P_BIAS_VOLTAGE

********************************************
********************************************
********************************************
